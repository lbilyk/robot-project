# Keil uVision project StarterTemplate.uvprojx, settings and files
target Target 1 (6070000::V6.7::.\ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StarterTemplate
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f303xe.s main.cpp main.h stm32f30x.h stm32f30x_conf.h system_stm32f30x.h SysTick.h DCmotors.h DCMotors.cpp system_stm32f30x.cpp SysTick.cpp stm32f30x_gpio.cpp stm32f30x_gpio.h stm32f30x_rcc.h stm32f30x_rcc.cpp stm32f30x_tim.cpp stm32f30x_tim.h LCD_display.h LCD_dispay.cpp pwmInit.cpp pwmInit.h stepper.h stepper.cpp limitSwitches.cpp limitSwitches.h USARTSystem.cpp Utilities.cpp USARTSystem.h Utilities.h stm32f30x_misc.h stm32f30x_misc.cpp stm32f30x_usart.cpp stm32f30x_usart.h stm32f30x_exti.h stm32f30x_exti.cpp ext_int.cpp ext_int.h ssd1306.h ssd1306.cpp ssd1306_fonts.cpp ssd1306_fonts.h
software components: CMSIS:CORE 5.1.2
